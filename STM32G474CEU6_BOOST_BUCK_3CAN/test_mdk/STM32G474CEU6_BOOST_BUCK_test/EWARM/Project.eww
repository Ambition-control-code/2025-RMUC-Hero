<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32G474CEU6_BOOST_BUCK.ewp</path>
  </project>
  <batchBuild />
</workspace>
