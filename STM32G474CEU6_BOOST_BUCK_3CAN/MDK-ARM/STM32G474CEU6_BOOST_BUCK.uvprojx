# Keil uVision project STM32G474CEU6_BOOST_BUCK.uvprojx, settings and files
target STM32G474CEU6_BOOST_BUCK (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G474CEUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G474CEU6_BOOST_BUCK +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;./USER/LCD16080;./USER/ADC_analyse;./USER/Power_protection;./USER/U_I_control;./USER/Communicaton;./USER/queue_list;./USER/Fast_math;./USER/Motor_Set;./USER/Flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c cordic.c dma.c fdcan.c hrtim.c spi.c tim.c usart.c usb.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group LCD16080
    ./USER/LCD16080/: lcd.c lcd_init.c lcd_ui_show.c
  group ADC_analyse
    ./USER/ADC_ANALYSE/: power_measurement.c
  group Power_protection
    ./USER/Power_protection/: power_protection.c
  group U_I_CTRL
    ./USER/U_I_control/: pid.c u_i_pid.c
  group Communication
    ./USER/Communicaton/: User_can.c User_usart.c User_Dbus.c KEY_3.c
    ./USER/queue_list/: queue_list.c UmpireData.c CRC8_16.c USE_DRAW.c UmpireDraw.c
  group Fast_math
    ./USER/Fast_math/: fast_math.c
  group Motor_Set
    ./USER/Motor_Set/: motor.c chassis_ctrl.c power_limit.c
  group Flash
    ./USER/Flash/: STMflash.c DATA_INIT.c
software components: CMSIS:CORE 5.6.0
