# Keil uVision project Running_away_with_a_bucket_3.0.uvprojx, settings and files
target Running_away_with_a_bucket_3.0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F446RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: debug +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F446xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__CC_ARM,__FPU_PRESENT =1U
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../DSP/Include;../HARDWARE;../HARDWARE/MOTOR;../HARDWARE/STMFLASH;../HARDWARE/IMU;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../bucket/ADRC;../bucket/MI_Cyber_Gear;../bucket/pid_is;../HARDWARE/rc;../bucket/referee_system;../bucket/kalman_1;../bucket/ulitility_tools;../bucket/Power_control;../bucket/TEST_ALL;../bucket/chassis_control_balance;../bucket/unitreeMotor;../bucket/unitreeMotor/include;../bucket/kalman_whx;../bucket/bsp_all;../task/gimbal_task;../task/vision_task;../task/refree_all;../task/gimbal_to_chassis;../bucket/rv_vision;../bucket/Fusion;../task/imu_task;../bucket/MadgwickAHRS;../task/shoot_task;../bucket/VMC;../task/balance_task;../task/speed_kalman_task;../bucket/algorithm/inc;../bucket/kalman_fliter
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group bucket
    ../bucket/ADRC/: ADRC_core.c
    ../bucket/MI_Cyber_Gear/: MI_Cyber_Gear.c
    ../bucket/pid_is/: pid_is.c
    ../bucket/referee_system/: referee_system.c
    ../bucket/ulitility_tools/: ulitility_tools.c
    ../bucket/Power_control/: Power_control.c
    ../bucket/unitreeMotor/include/: motor_msg_GO-M8010-6.h
    ../bucket/bsp_all/: bsp_dwt.c
    ../bucket/rv_vision/: SolveTrajectory.c
    ../bucket/MadgwickAHRS/: MadgwickAHRS.c
    ../bucket/VMC/: VMC_calc.c
    ../bucket/kalman_1/: kalman.c
    ../bucket/algorithm/src/: lqr.c
    ../bucket/kalman_fliter/: kalman_filter.c QuaternionEKF.c
  group DSP
    ../HARDWARE/: AHRS.lib AHRS_middleware.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/MOTOR/: MOTOR.c
    ../DSP/: arm_cortexM4lf_math.lib
  group HARDWARE
    ../HARDWARE/IMU/: BMI088driver.c BMI088Middleware.c bsp_imu_pwm.c
    ../HARDWARE/rc/: rc.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group task
    ../task/gimbal_task/: gimbal_task.c
    ../task/vision_task/: vision_task.c
    ../task/refree_all/: refree_task.c
    ../task/gimbal_to_chassis/: gimbal_to_chassis.c
    ../task/imu_task/: imu_task.c
    ../task/shoot_task/: shoot_task.c
    ../task/balance_task/: balance_task.c
    ../task/speed_kalman_task/: speed_kalman_task.c
software components: CMSIS:CORE 5.6.0
